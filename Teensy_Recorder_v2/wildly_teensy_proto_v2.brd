# Repository wildlytech/wildly_listen_hardware

File README.md:

# wildly_listen_hardware
 Repo for the hardware design files of Wildly Listen development in modules.

This is the Hardware Development/ Design repository of Wildly Listen, real time acoustic monitoring device.

All folders include Schematics, Board layout and BOM.

All development work has been done on Eagle CAD unless otherwise mentioned.

## EAGLE design Teensy_Recorder_v2/wildly_teensy_proto_v2.brd

Parts:
BATT: B2B-PH-SM4-TB(LF)(SN); JST_B2B-PH-SM4-TB(LF)(SN)
BATT_VA_MON: JP1Q; JP1
BATT_V_MON: JP1Q; JP1
C1: 10uF; C0805
C2: 100nF; C0805
C3: 1.0uF; C0805
C4: 0.47uF; C0805
ERRLED: LEDCHIP-LED0805; CHIP-LED0805
LED_JUMPER: JP1Q; JP1
ON-OFF-SWITCH: Power; 3PIN_SLIDE_SWITCH
R1, R2, R3: 1.65KR; M0805
R4, R5, R6: 870R; M0805
R7, R8: 0R; M0805
R9: 0.01; 1206
R10, R11: 4.7K; R0805
R12, R14: 10K; R0805
R13: 0R; R0805
RECLED: LEDCHIP-LED0805; CHIP-LED0805
SDLED: LEDCHIP-LED0805; CHIP-LED0805
SOLAR_CHARGER: 61300211121
T1, T2, T3: BC847BLT1G; SOT96P237X111-3N
TEENSY_PIN_1, TEENSY_PIN_2, TEENSY_PIN_3, TEENSY_PIN_4, TEENSY_PIN_5, TEENSY_PIN_6, TEENSY_PIN_7, TEENSY_PIN_8: PINHD-1X6; 1X06
U1: BQ27441-G1; PDSO-N12
U$1: TEENSY3_6--ALLPINS; T36
WIILDLY_GSM: PINHD-1X10; 1X10
WILDLY_I2S_MIC: PINHD-1X6; 1X06
WILDLY_RTC: MA04-1

Connections:
3V: LED_JUMPER.2, TEENSY_PIN_3.3, TEENSY_PIN_5.3, U$1.3V3(1) (3V3), U$1.3V3(2) (3V3), U$1.3V3(3) (3V3), U$1.3V3(4) (3V3), WIILDLY_GSM.1, WILDLY_I2S_MIC.1, WILDLY_RTC.1
25: TEENSY_PIN_3.5, U$1.25
+3V3: LED_JUMPER.1, R4.2, R5.2, R6.2
A0: TEENSY_PIN_7.1, U$1.14 (14/A0/PWM/ALT-SCK0)
A1: TEENSY_PIN_6.6, U$1.15 (15/A1/CS0-4/T)
A2: TEENSY_PIN_6.5, U$1.16 (16/A2/PWM/T/ALT-SCL0)
AGND: TEENSY_PIN_5.2, U$1.AGND
ALT-MOSI: TEENSY_PIN_4.2, U$1.28 (28/ALT-MOSI0)
ALT-PWM: TEENSY_PIN_3.6, U$1.26 (26/ALT-PWM/ALT-TX1/ALT-SCL2)
ALT-RX1: TEENSY_PIN_4.1, U$1.27 (27/ALT-RX1/ALT-SCK0)
BIN: R13.2, U1.10 (BIN)
CTS_OF_GSM: TEENSY_PIN_8.6, U$1.33 (33/A14/CAN1TX/TX5/ALT-SCL0), WIILDLY_GSM.6
DAC0: TEENSY_PIN_7.5, U$1.DAC0
DAC1: TEENSY_PIN_7.4, U$1.DAC1
ERRLED: R3.1, TEENSY_PIN_7.6, U$1.39 (39/A20/ALT-MISO0)
GND: BATT.2, C1.2, C2.2, C3.2, C4.2, R14.1, SOLAR_CHARGER.2, T1.2 (E), T2.2 (E), T3.2 (E), TEENSY_PIN_1.1, TEENSY_PIN_7.3, U1.3 (VSS), U1.EP (PWPD), U1.EP1 (PWPD), U1.EP2 (PWPD), U1.EP3 (PWPD), U1.EP4 (PWPD), U$1.G0 (GND), U$1.G1 (GND), U$1.G2 (GND), U$1.G3 (GND), U$1.G4 (GND), U$1.G5 (GND), U$1.G6 (GND), WIILDLY_GSM.2, WILDLY_I2S_MIC.2, WILDLY_RTC.2
GPOUT: R12.1, U1.12 (GPOUT)
MISO: TEENSY_PIN_3.2, U$1.12 (12/MISO0)
MOSI: TEENSY_PIN_3.1, U$1.11 (11/MOSI0)
unnamed: SDLED.C, T3.3 (C)
unnamed: RECLED.C, T2.3 (C)
unnamed: R2.2, T2.1 (B)
unnamed: ERRLED.C, T1.3 (C)
unnamed: R13.1, R14.2
unnamed: R3.2, T1.1 (B)
unnamed: R4.1, SDLED.A
unnamed: R7.1, WIILDLY_GSM.3
unnamed: R1.2, T3.1 (B)
unnamed: R8.1, WIILDLY_GSM.4
unnamed: R6.1, RECLED.A
unnamed: ERRLED.A, R5.1
NETSTAT: U$1.24, WIILDLY_GSM.9
NETSTATLED: TEENSY_PIN_8.1
NET_STAT: TEENSY_PIN_3.4
POWER_CONTROL: TEENSY_PIN_8.4, U$1.35 (35/A16/PWM), WIILDLY_GSM.10
PWM: TEENSY_PIN_2.5, U$1.9 (9/PWM/RX2/CS0-1), WILDLY_I2S_MIC.3
PWM1: TEENSY_PIN_1.4, U$1.2 (2/PWM)
PWM2: TEENSY_PIN_1.5, U$1.3 (3/PWM/SCL2/CAN0TX)
PWM3: TEENSY_PIN_1.6, U$1.4 (4/PWM/SDA2/CAN0RX)
PWM4: TEENSY_PIN_2.1, U$1.5 (5/PWM/ALT-TX1/ALT-MISO1)
PWM5: TEENSY_PIN_2.2, U$1.6 (6/PWM)
PWM6: TEENSY_PIN_2.3, U$1.7 (7/PWM/RX3/ALT-SCL0/ALT-MOSI0)
PWM7: TEENSY_PIN_2.4, U$1.8 (8/PWM/TX3/ALT-SDA0/ALT-MISO0)
PWM8: TEENSY_PIN_2.6, U$1.10 (10/PWM/TX2/CS0-0)
PWM9: TEENSY_PIN_4.3, U$1.29 (29/PWM/T/ALT-CAN0TX)
PWM10: TEENSY_PIN_4.4, U$1.30 (30/PWM/T/ALT-CAN0RX)
PWM11: TEENSY_PIN_4.5, U$1.31 (31/A12/PWM/RX4/CS1-0)
PWM12: TEENSY_PIN_4.6, U$1.32 (32/A13/PWM/TX4/SCK1)
PWM13: TEENSY_PIN_5.6, U$1.21 (21/A7/PWM/CS0-3/ALT-MOSI1/ALT-RX1)
PWM14: TEENSY_PIN_5.5, U$1.22 (22/A8/PWM/T)
PWM_SARA: TEENSY_PIN_6.4, U$1.17 (17/A3/PWM/T/ALT-SDA0), WIILDLY_GSM.8
RECLED: R2.1, TEENSY_PIN_8.3, U$1.36 (36/A17/PWM)
RESET_GSM: TEENSY_PIN_6.1, U$1.20 (20/A6/PWM/CS0-2/ALT-SCK1), WIILDLY_GSM.7
RST: TEENSY_PIN_7.2, U$1.13 (13/LED/ALT-PWM/SCK0), WILDLY_I2S_MIC.4
RTS_OF_GSM: TEENSY_PIN_8.5, U$1.34 (34/A15/CAN1RX/RX5/ALT-SDA0), WIILDLY_GSM.5
RX: TEENSY_PIN_5.4, U$1.23 (23/A9/PWM/T), WILDLY_I2S_MIC.5
RX_OF_GSM: R7.2, TEENSY_PIN_1.3, U$1.1 (1/TX1/MISO1/T)
SCL: R11.1, TEENSY_PIN_6.2, U1.2 (SCL), U$1.19 (19/A5/PWM/T/SCL0), WILDLY_RTC.3
SDA: R10.1, TEENSY_PIN_6.3, U1.1 (SDA), U$1.18 (18/A4/PWM/T/SDA0), WILDLY_RTC.4
SDLED: R1.1, TEENSY_PIN_8.2, U$1.37 (37/A18/PWM/SCL1)
TX_OF_GSM: R8.2, TEENSY_PIN_1.2, U$1.0 (0/RX1/MOSI1/T)
VCC: BATT.1, ON-OFF-SWITCH.1, SOLAR_CHARGER.1
VCCIO: BATT_VA_MON.2, R9.1, U1.7 (SRN)
VDD: C4.1, U1.5 (VDD)
VIN: BATT_VA_MON.1, BATT_V_MON.1, C1.1, C2.1, ON-OFF-SWITCH.2 (COM), TEENSY_PIN_5.1, U$1.VIN
V_FG: BATT_V_MON.2, C3.1, R9.2, R10.2, R11.2, R12.2, U1.6 (BAT), U1.8 (SRP)

Notes on the sheet:
ON/OFF
Solar Charger
LiPo Battery Connector
Note - When powering the board from boost R4 = 0 ohm should be mounted
Fuel Gauge
Wildly UBLOX GSM Board
Wildly I2S Microphone SPH0645LM4H
Wildly RTC
VDD is 1.8V generated internally
I2C ADDR: 0x55

Board: 2 copper layers, 55.1 x 78.0 mm, 43 parts (0 on the bottom side), 64 nets.

## EAGLE design Wildly_Multi_Lipo_Charger/Wildly_4Lipo_Charge.brd

Parts:
C1: 4700uF/10V; E5-13
C2: 10uF; C0805K
C11, C12, C21, C22, C31, C32, C41, C42: 10µF; 0805-NO
CN1, CN2, CN3, CN4: JSTPH; JSTPH2
CN5: DCIN; DCJACK_2MM_SMT
D1, D2, D3, D4, D6: MBR120VLSFT1G; SOD-123
DCIN_6V: BATT; 1X02_ROUND
JP1, JP2, JP3, JP4, JP101, JP201, JP301, JP401: HEADER-1X2ROUND; 1X02_ROUND
JP11, JP22, JP33, JP44: PINHD-1X1CB; 1X01-CLEANBIG
LED11, LED21, LED31, LED41: RED; CHIPLED_0805_NOOUTLINE
LED12, LED22, LED32, LED42: GREEN; CHIPLED_0805_NOOUTLINE
R1, R2, R3, R4: 0; R0805
R101, R102, R201, R202, R301, R302, R401, R402: 470; 0805-NO
R103, R203, R303, R403: 2K\; 0805-NO
U1, U2, U3, U4: MCP73831T-2ACI/OT; SOT23-5
X1, X2, X3, X4: USB_MEDIUM; USB-MINI_MEDIUM

Connections:
GND: C1.-, C2.2, C11.2, C12.2, C21.2, C22.2, C31.2, C32.2, C41.2, C42.2, CN1.1, CN2.1, CN3.1, CN4.1, CN5.GND (GNDBREAK), CN5.GNDBREAK (GND), DCIN_6V.1, JP1.2, JP2.2, JP3.2, JP4.2, JP101.2, JP201.2, JP301.2, JP401.2, LED12.C, LED22.C, LED32.C, LED42.C, R103.2, R203.2, R303.2, R403.2, U1.2 (VSS), U2.2 (VSS), U3.2 (VSS), U4.2 (VSS), X1.GND, X1.GND1 (GND), X1.GND2 (GND), X1.GND3 (GND), X1.GND4 (GND), X2.GND, X2.GND1 (GND), X2.GND2 (GND), X2.GND3 (GND), X2.GND4 (GND), X3.GND, X3.GND1 (GND), X3.GND2 (GND), X3.GND3 (GND), X3.GND4 (GND), X4.GND, X4.GND1 (GND), X4.GND2 (GND), X4.GND3 (GND), X4.GND4 (GND)
unnamed: LED21.C, R201.1
unnamed: JP22.1, R201.2, R202.2, U2.1 (STAT)
unnamed: LED11.C, R101.1
unnamed: R203.1, U2.5 (PROG)
unnamed: LED22.A, R202.1
unnamed: JP11.1, R101.2, R102.2, U1.1 (STAT)
unnamed: R103.1, U1.5 (PROG)
unnamed: LED12.A, R102.1
unnamed: D3.C, R3.1, X3.VBUS
unnamed: LED31.C, R301.1
unnamed: JP33.1, R301.2, R302.2, U3.1 (STAT)
unnamed: R303.1, U3.5 (PROG)
unnamed: LED32.A, R302.1
unnamed: LED41.C, R401.1
unnamed: JP44.1, R401.2, R402.2, U4.1 (STAT)
unnamed: R403.1, U4.5 (PROG)
unnamed: LED42.A, R402.1
unnamed: C1.+, C2.1, CN5.PWR, D6.A, DCIN_6V.2
unnamed: D2.C, R2.1, X2.VBUS
unnamed: D1.C, R1.1, X1.VBUS
unnamed: D4.C, R4.1, X4.VBUS
VBAT: C22.1, CN2.2, JP201.1, U2.3 (VBAT)
VBAT1: C12.1, CN1.2, JP101.1, U1.3 (VBAT)
VBAT2: C32.1, CN3.2, JP301.1, U3.3 (VBAT)
VBAT3: C42.1, CN4.2, JP401.1, U4.3 (VBAT)
VCC: D1.A, D2.A, D3.A, D4.A, D6.C
VDD1: C11.1, JP1.1, LED11.A, R1.2, U1.4 (VDD)
VDD2: C21.1, JP2.1, LED21.A, R2.2, U2.4 (VDD)
VDD3: C31.1, JP3.1, LED31.A, R3.2, U3.4 (VDD)
VDD4: C41.1, JP4.1, LED41.A, R4.2, U4.4 (VDD)

Notes on the sheet:
10K = 100mA
5.0K = 200mA
2.0K = 500mA
1.0K = 1000mA

Board: 2 copper layers, 81.0 x 47.0 mm, 65 parts (0 on the bottom side), 31 nets.

## EAGLE design PowerBoost - BASIC/Adafruit PowerBoost 1000 Basic.brd

Parts:
B1: 1.8-5V; JSTPH2
C1: 10uF; 0805-NO
C2: 2.2uF; 0805-NO
C3, C6: 100uF; C1210
C4: 0.1uF; 0805-NO
JP2: HEADER-1X8ROUND; 1X08_ROUND
L1: 6.8uH; INDUCTOR_8X8MM
LED1: RED; CHIPLED_0805_NOOUTLINE
LED2: GREEN; CHIPLED_0805_NOOUTLINE
R1, R3: 1.87M; _0805MP
R2: 340K; _0805MP
R4, R13: 200K; 0805-NO
R5, R20: 1K; 0805-NO
T1: MMUN2133LT1G; SC59-BEC
U1: TPS61030RSAR; PVQFN-16
X1: TERMBLOCK_1X2; TERMBLOCK_1X2-3.5MM
X2: 3.5mm; TERMBLOCK_1X2-3.5MM

Connections:
5.0V: C2.1, C3.1, C6.1, JP2.8, R3.2, R5.1, U1.1 (VOUT), U1.15 (VOUT), U1.16 (VOUT), X1.2
ENABLE: JP2.4, R13.2, U1.11 (EN)
GND: B1.1 (-), C1.2, C2.2, C3.2, C4.2, C6.2, JP2.5, JP2.7, LED1.C, LED2.C, R2.1, R4.1, U1.5 (PGND), U1.6 (PGND), U1.7 (PGND), U1.10 (SYNC), U1.13 (GND), U1.P$18 (PGND), U1.P$19 (PGND), U1.P$20 (PGND), U1.P$21 (PGND), U1.P$22 (PGND), U1.THERMAL (PGND), X1.1, X2.1
LBO: JP2.6, T1.B, U1.12 (LBO)
unnamed: L1.P$2 (2), U1.3 (SW), U1.4 (SW)
unnamed: LED1.A, R20.1
unnamed: R1.1, R2.2, U1.9 (LBI)
unnamed: LED2.A, R5.2
unnamed: R3.1, R4.2, U1.14 (FB)
unnamed: R20.2, T1.C
VBAT: B1.2 (+), C1.1, C4.1, JP2.2, L1.P$1 (1), R1.2, R13.1, T1.E, U1.8 (VBAT), X2.2

Notes on the sheet:
Both grounds must be connected on the PCB at only one point close to the GND pin.
On/Off Switch
See Pg 15 1st para
6.8uH power w/4A current
R3 = 1.9Mohm for 5.2V R3 = 1.1Mohm for 3.3V

Board: 2 copper layers, 29.2 x 22.9 mm, 25 parts (0 on the bottom side), 11 nets.

Other parts of the board:
U$12, U$26: SYMBOL_MINUS
U$13, U$25: SYMBOL_PLUS

## EAGLE design MCP73871-Solar Charger/Adafruit MCP73871 Solar Charger v4.brd

File MCP73871-Solar Charger/readme.md:

# Solar charging module for Wildly Listen

Used with 6V solar panels and interfaced to 3.7v Li-Ion battery

Parts:
BATT: JST_2PIN-SMT-RA; JST-PH-2-SMT-RA
C1, C2, C3: 10uF; C0805K
C4: 4700uF/10V; E5-13
CHRG/LBO: ORANGE; CHIPLED_0805_NOOUTLINE
CN1: DCIN; DCJACK_2MM_SMT
CN4: USBMINIBLARGE; USB-MINIB_LARGER
D1: MBR120VLSFT1G; SOD-123
DONE: GREEN; CHIPLED_0805_NOOUTLINE
JP1, JP4: BATT; 1X02_ROUND
JP3: LOAD; 1X02_ROUND
JP5: PINHD-1X3CB; 1X03-CLEANBIG
LOAD: JST_2PIN-SMT-RA; JST-PH-2-SMT-RA
PWR: RED; CHIPLED_0805_NOOUTLINE
R1: 0; R0805
R2: 270K; R0805
R3, R12: 100K; R0805
R5: 1K; M0805
R8, R9, R10: 1K; R0805
R11: 2K; 0805-THM
RT2: 150K; M0805
THERM: 10K; 0805-THM
U1: MCP73871; QFN20_4MM
U$2, U$3, U$8: FIDUCIAL; FIDUCIAL_1MM
U$4, U$5, U$6, U$7: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED

Connections:
BATT: BATT.1 (2), C2.1, JP4.1, U1.P$14 (VBAT1), U1.P$15 (VBAT2), U1.P$16 (VBAT3)
GND: BATT.2 (1), C1.2, C2.2, C3.2, C4.-, CN1.GND (GNDBREAK), JP1.1, JP3.2, JP4.2, LOAD.2 (1), R3.2, R11.1, R12.1, RT2.1, THERM.1, U1.P$10 (GND1), U1.P$11 (GND2), U1.P$21 (GND3)
unnamed: PWR.C, U1.P$6 (/PG)
unnamed: CN4.VBUS, R1.1
unnamed: CN1.GNDBREAK (GND), CN4.GND, CN4.GND1 (GND), CN4.GND2 (GND), CN4.GND3 (GND), CN4.GND4 (GND)
unnamed: DONE.C, JP5.3, U1.P$7 (STAT2)
unnamed: R5.1, U1.P$5 (THERM)
unnamed: R2.1, R3.1, U1.P$2 (VPCC)
unnamed: R5.2, RT2.2, THERM.2
unnamed: CN1.PWR, D1.A
unnamed: CHRG/LBO.C, JP5.1, U1.P$8 (STAT1/LBO)
unnamed: CHRG/LBO.A, R8.1
unnamed: DONE.A, R9.1
unnamed: PWR.A, R10.1
unnamed: R12.2, U1.P$12 (PROG3)
unnamed: R11.2, U1.P$13 (PROG1)
OUT: C1.1, JP3.1, LOAD.1 (2), U1.P$1 (OUT1), U1.P$20 (OUT2)
VCC: C3.1, C4.+, D1.C, JP1.2, JP5.2, R1.2, R2.2, R8.2, R9.2, R10.2, U1.P$3 (SEL), U1.P$4 (PROG2), U1.P$9 (/TE), U1.P$17 (CE), U1.P$18 (IN1), U1.P$19 (IN2)

Notes on the sheet:
Charge Rate = 1000V/PROG1
1.0K = 1000mA
2.0K = 500mA
No Thermistor:
10K NTC Thermistor:
RT1 = 0, RT2 = 10K
RT1 = TBD, RT2 = TBD

Board: 2 copper layers, 40.7 x 33.0 mm, 35 parts (0 on the bottom side), 18 nets.

## EAGLE design PowerBoost - with Charging Circuit/Adafruit PowerBoost 1000C.brd

Parts:
B1: JST 2-PH; JSTPH2
C1, C7, C8: 10uF; 0805-NO
C2: 2.2uF; 0805-NO
C4: 0.1uF; 0805_10MGAP
C6: 100uF; C1210
CHRG/LBO: ORANGE; CHIPLED_0805_NOOUTLINE
CN1: USBA_FEMALE; USB_HOST-PTH
CN4: MicroUSB; 4UCONN_20329
DONE: GREEN; CHIPLED_0805_NOOUTLINE
FID1, FID2, FID3: FIDUCIAL""; FIDUCIAL_1MM
JP2: HEADER-1X8ROUND; 1X08_ROUND
L1: 6.8uH; INDUCTOR_5X5MM_TDK_VLC5045
LED1: RED; CHIPLED_0805_NOOUTLINE
LED2: BLUE; CHIPLED_0805_NOOUTLINE
R1: 1.87M; _0805MP
R2: 340K; _0805MP
R3: 1.87M; 0805-NO
R4, R13: 200K; 0805-NO
R5, R8, R14, R20: 1K; 0805-NO
R6: 270K; 0805-NO
R7, R17: 100K; 0805-NO
R9: 43K; 0805-NO
R10: 49.9K; 0805-NO
R11: 75K 1%; 0805-NO
R12: 49.9K 1%; 0805-NO
R16: 1.0K; 0805-NO
T1: MMUN2133LT1G; SC59-BEC
THERM: 15K; 0805-NO
U1: TPS61090RSAR; PVQFN-16
U2: MCP73871; QFN20_4MM
U$10, U$11: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED
X1: TERMBLOCK_1X2; TERMBLOCK_1X2-3.5MM

Connections:
5.0V: C2.1, C6.1, CN1.VBUS, JP2.8, R3.2, R5.1, R9.2, R11.2, U1.1 (VOUT), U1.15 (VOUT), U1.16 (VOUT), X1.2
D+: CN1.D+, R11.1, R12.1
D-: CN1.D-, R9.1, R10.1
ENABLE: JP2.4, R13.2, U1.11 (EN)
GND: B1.1 (-), C1.2, C2.2, C4.2, C6.2, C7.2, C8.2, CN1.GND, CN4.BASE@1 (GND), CN4.BASE@2 (GND), CN4.GND, CN4.SPRT@1 (GND), CN4.SPRT@2 (GND), CN4.SPRT@3 (GND), CN4.SPRT@4 (GND), JP2.5, JP2.7, LED1.C, LED2.C, R2.1, R4.1, R7.2, R10.2, R12.2, R16.1, R17.1, THERM.1, U1.5 (PGND), U1.6 (PGND), U1.7 (PGND), U1.10 (SYNC), U1.13 (GND), U1.P$18 (PGND), U1.P$19 (PGND), U1.P$20 (PGND), U1.P$21 (PGND), U1.P$22 (PGND), U1.THERMAL (PGND), U2.P$10 (VSS1), U2.P$11 (VSS2), U2.P$21 (THERMAL), X1.1
LBO: JP2.6, T1.B, U1.12 (LBO)
unnamed: L1.P$2 (2), U1.3 (SW), U1.4 (SW)
unnamed: LED1.A, R20.1
unnamed: R1.1, R2.2, U1.9 (LBI)
unnamed: LED2.A, R5.2
unnamed: R3.1, R4.2, U1.14 (FB)
unnamed: R20.2, T1.C
unnamed: R6.1, R7.1, U2.P$2 (VPCC)
unnamed: DONE.C, R14.2
unnamed: R14.1, U2.P$7 (STAT2)
unnamed: THERM.2, U2.P$5 (THERM)
unnamed: R8.1, U2.P$8 (STAT1/LBO)
unnamed: CHRG/LBO.C, R8.2
unnamed: R17.2, U2.P$12 (PROG3)
unnamed: R16.2, U2.P$13 (PROG1)
VBAT: C1.1, C4.1, JP2.3, L1.P$1 (1), R1.2, R13.1, T1.E, U1.8 (VBAT), U2.P$1 (VOUT1), U2.P$20 (VOUT2)
VBUS: C8.1, CHRG/LBO.A, CN4.VBUS, DONE.A, JP2.1, R6.2, U2.P$3 (SEL), U2.P$4 (PROG2), U2.P$9 (/TE), U2.P$17 (CE), U2.P$18 (VIN1), U2.P$19 (VIN2)
VLIPO: B1.2 (+), C7.1, JP2.2, U2.P$14 (VBAT1), U2.P$15 (VBAT2), U2.P$16 (VBATSENS)

Notes on the sheet:
Both grounds must be connected on the PCB at only one point close to the GND pin.
On/Off Switch
See Pg 15 1st para
6.8uH power w/2A current
R3 = 1.9Mohm for 5.2V R3 = 1.1Mohm for 3.3V
Charge Rate = 1000V/PROG1
1.0K = 1000mA
2.0K = 500mA
No Thermistor:
10K NTC Thermistor:
RT1 = 0, RT2 = 10K
RT1 = TBD, RT2 = TBD

Board: 2 copper layers, 36.1 x 22.9 mm, 45 parts (1 on the bottom side), 23 nets.

Other parts of the board:
U$12: PCBFEAT-REV-040
U$25: SYMBOL_PLUS
U$26: SYMBOL_MINUS

File PowerBoost - with Charging Circuit/Powerboost 1000C BOM.xlsx:

Powerboost_1000C_BOM
S. No | Part | Value | Device | Package | Description | Digikey link | Mnfr P/N | Manufacturer | Quantity
1 | C1,C7,C8 | 10uF | CAP_CERAMIC0805-NOOUTLINE | 0805-NO | Ceramic Capacitors
2 | C2 | 2.2uF | CAP_CERAMIC0805-NOOUTLINE | 0805-NO | Ceramic Capacitors
3 | C4 | 0.1uF | CAP_CERAMIC0805_10MGAP | 0805_10MGAP | Ceramic Capacitors
4 | C3,C6 | 100uF | C-USC1210 | C1210 | CAPACITOR, American symbol
5 | L1 | 6.8uH | INDUCTORTDK_VLC5045 | INDUCTOR_5X5MM_TDK_VLC5045 | Inductors
6 | R1,R3 | 1.87M | RESISTOR_0805MP | _0805MP | Resistors
7 | R2 | 340K | RESISTOR_0805MP | _0805MP | Resistors
8 | R4,R13 | 200K | RESISTOR0805_NOOUTLINE | 0805-NO | Resistors
9 | R5,R8,R14,R16,R20 | 1K | RESISTOR0805_NOOUTLINE | 0805-NO | Resistors
10 | R6 | 270K | RESISTOR0805_NOOUTLINE | 0805-NO | Resistors
11 | R7,R17 | 100K | RESISTOR0805_NOOUTLINE | 0805-NO | Resistors
12 | R9 | 43K , 1% | RESISTOR0805_NOOUTLINE | 0805-NO | Resistors
13 | R10 | 49.9K , 1% | RESISTOR0805_NOOUTLINE | 0805-NO | Resistors
14 | R11 | 75K 1% | RESISTOR0805_NOOUTLINE | 0805-NO | Resistors
15 | R12 | 49.9K 1% | RESISTOR0805_NOOUTLINE | 0805-NO | Resistors
16 | THERM | 15K | RESISTOR0805_NOOUTLINE | 0805-NO | Resistors
17 | T1 | MMUN2133LT1G | MUN2114T1-PNP_DRIVER-SC59-BEC | SC59-BEC | PNP Bias Resistor Transistor
18 | CN4 | MicroUSB | USBMICRO_20329 | 4UCONN_20329 | USB Connectors
19 | U1 | TPS61090RSAR | VREG_TPS6103X | PVQFN-16 | TPS6103x 4A Boost - 1.8-5.5V Input, Adjustable Output to 5.5V
20 | U2 | MCP73871 | MCP73871 | QFN20_4MM | MCP73871 Lithium Polymer Battery Charger
21 | LED1 | RED | LED0805_NOOUTLINE | CHIPLED_0805_NOOUTLINE | LED
22 | LED2 | BLUE | LED0805_NOOUTLINE | CHIPLED_0805_NOOUTLINE | LED
23 | DONE | GREEN | LED0805_NOOUTLINE | CHIPLED_0805_NOOUTLINE | LED
24 | CHRG/LBO | ORANGE | LED0805_NOOUTLINE | CHIPLED_0805_NOOUTLINE | LED

Notices in the files:
parts and their libraries:
SparkFun-Resistors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
microbuilder: This work is placed in the public domain, and may be freely used for commercial and non-commercial work with the following conditions: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
