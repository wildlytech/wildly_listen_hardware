# Repository wildlytech/wildly_listen_hardware (continued)

## EAGLE design SPH0645LM4H- I2S Mic/I2S Mic with 0603 resistors.brd

Parts:
C2: 220pF; 0805-NO
C4: 1uF; 0805-NO
FID1, FID2: FIDUCIAL_1MM
IC1: MIC_I2S_SPH0645; SPH0645LM4H
JP2: HEADER-1X6ROUND; 1X06_ROUND
R1: 68; 0603-NO
R2: 10k; 0603-NO
U$6, U$12: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED

Connections:
BCLK: IC1.4 (BCLK), JP2.3
DATA: JP2.4, R1.2
GND: C2.2, C4.2, IC1.3 (GND), JP2.2, R2.1
unnamed: IC1.6 (DATA), R1.1
SELECT: IC1.2 (SELECT), JP2.6, R2.2
VDD: C2.1, C4.1, IC1.5 (VDD), JP2.1
WS: IC1.1 (WS), JP2.5

Notes on the sheet:
WILDLY I2S MIC

Board: 2 copper layers, 16.5 x 12.7 mm, 11 parts (9 on the bottom side), 7 nets.

Other parts of the board:
U$13: PCBFEAT-REV-040

File SPH0645LM4H- I2S Mic/I2S Mic BOM.xlsx:

I2S_MIC_BOM
S. No | Part | Value | Device | Package | Description | Digikey link | Mnfr P/N | Manufacturer | Quantity
1 | C4 | 1uF | CAP-CERAMIC0805-NOOUTLINE | 0805-NO | Ceramic capacitors
2 | C2 | 220pF | CAP-CERAMIC0805-NOOUTLINE | 0805-NO | Ceramic capacitors
3 | R1 | 68R | R-US_M0805 | M0805 | RESISTOR
4 | R2 | 10K | R-US_M0805 | M0805 | RESISTOR
5 | IC1 |  | MIC_I2S_SPH0645 | SPH0645LM4H | CRAWFORD MIC DGT I2S BOTTOM PORT

## EAGLE design FUEL_GAUGE_BQ27441-G1/lipo_fuel_gauge-v11.brd

File FUEL_GAUGE_BQ27441-G1/readme.md:

# Module for battery voltage and current monitoring in Wildly Listen hardware#

Fuel gauge monitoring module using TI- BQ27441-G1 for Teensy protoboard v2, use jumper configuration for appropriate voltage or voltage + current monitoring

Parts:
C1: 1.0uF; C0805
C2: 0.47uF; C0805
JP1: Input; JST-2-SMD
JP2, JP4: M03PTH; 1X03
JP5: M02PTH; 1X02
R1: 0.01; 1206
R2, R3: 4.7K; R0805
R4, R6: 10K; R0805
R5: 0R; R0805
U1: BQ27441-G1; PDSO-N12

Connections:
BIN: R5.2, U1.10 (BIN)
GND: C1.2, C2.2, JP1.1, JP2.3, JP4.2, JP5.2, R6.1, U1.3 (VSS), U1.EP (PWPD), U1.EP1 (PWPD), U1.EP2 (PWPD), U1.EP3 (PWPD), U1.EP4 (PWPD)
GPOUT: R4.1, U1.12 (GPOUT)
unnamed: R5.1, R6.2
SCL: JP2.2, R3.1, U1.2 (SCL)
SDA: JP2.1, R2.1, U1.1 (SDA)
VCC: C1.1, JP1.2, JP4.1, JP5.1, R1.2, R2.2, R3.2, R4.2, U1.6 (BAT), U1.8 (SRP)
VCCIO: JP4.3, R1.1, U1.7 (SRN)
VDD: C2.1, U1.5 (VDD)

Notes on the sheet:
VDD is 1.8V generated internally
I2C ADDR: 0x55

Board: 2 copper layers, 10.2 x 24.1 mm, 13 parts (7 on the bottom side), 9 nets.

## EAGLE design SARA_U201_BREAKOUT_BOARD/SARA_U201.brd

Parts:
C3, C4, C6, C9, C10: 100nF; C0805
C5: 15pF; C0805
C7: 2.2uF; C0805
C8: 10uF; C0805
C11, C13: C-USC0805; C0805
C12: 33pF; C0805
C16: 100uF; C0805
C18, C19, C20, C21, C22: 47pF; C0805
IC1, IC2, IC4: SOT95P275X110-6N
IC3: MCP1826T-3302E_DC; SOT127P706X180-6N
IC5: TXB0106PWR; SOP65P640X120-16N
IC6: TS3USB221ERSER
IC7: SARA-U201-03B
IC8: TEENSY3_6--ALLPINS; T36
J1: SMA_CONNECTOR; LPRS_SMA_CONNECTOR
J2: B2B-PH-SM4-TB(LF)(SN); JST_B2B-PH-SM4-TB(LF)(SN)
J3: 61300211121
J4, J5: 61300311121
JP2, JP4: PINHD-1X4; 1X04
JP3: PINHD-1X9; 1X09
L2: 39nH; FB_BLM18PG121SN1D
LED1, LED3: SML-LX0805GC-TR; LEDC2012X120N
R1: 470; R0805
R2: 1k; R0805
R3, R20: 100K; R0805
R4, R5, R6: 0R; M0805
R11: 470K; R0805
R13, R17: 10K; R0805
R14: 1K; R0805
R15: 820R; R0805
R16: 47K; R0805
R18, R19: 4K7; R0805
SOLAR_CHARGER: 61300211121
SWITCH: GSM Power; 3PIN_SLIDE_SWITCH
T1: BC847; SOT23
TP1, TP2, TP3, TP5: TPB1,27; B1,27
USB: MICRO-USB-ZX62R-B-5P; ZX62R-B-5P
WILDLY_5V_1A_BOOST: PINHD-1X8BIG; 1X08-BIG
WILDLY_I2S_MIC: PINHD-1X6; 1X06
X1: CCM03-3013LFT_R102; C&K_CCM03-3013LFTR102

Connections:
5V_EN: SWITCH.1, WILDLY_5V_1A_BOOST.5
5V_SUPPLY: R4.2, WILDLY_5V_1A_BOOST.1
+5V: C11.1, C13.1, IC8.VIN, LED1.A, R4.1
ANT: C5.1, IC7.56 (ATN)
ANT_DET: IC7.62 (ANT_DET), JP3.9
CODEC_CLK: IC7.19 (CODEC_CLK), JP3.1
CTS: IC5.12 (B4), IC8.33 (33/A14/CAN1TX/TX5/ALT-SCL0)
CTS1: IC5.5 (A4), IC7.11 (CTS)
DCD1: IC7.8 (DCD)
DSR1: IC7.6 (DSR)
DTR1: IC7.9 (DTR)
FUEL_GAUGE_SCL: IC8.19 (19/A5/PWM/T/SCL0), J4.2
FUEL_GAUGE_SDA: IC8.18 (18/A4/PWM/T/SDA0), J4.1
GND: C3.2, C4.1, C6.1, C7.2, C8.2, C10.2, C11.2, C13.2, C16.2, C18.1, C19.1, C20.1, C21.1, C22.1, IC1.5 (GND_A), IC1.6 (GND_B), IC2.5 (GND_A), IC2.6 (GND_B), IC3.3 (GND), IC3.6 (GND_(TAB)), IC5.9 (GND), IC7.1 (GND_1), IC7.3 (GND_2), IC7.5 (GND_3), IC7.20 (GND_5), IC7.21 (GND_6), IC7.22 (GND_7), IC7.32 (GND_9), IC7.33 (RSVD_2), IC7.43 (GND_10), IC7.50 (GND_11), IC7.54 (GND_12), IC7.55 (GND_13), IC7.57 (GND_14), IC7.58 (GND_15), IC7.59 (GND_16), IC7.60 (GND_17), IC7.61 (GND_18), IC7.63 (GND_19), IC7.64 (GND_20), IC7.65 (GND_21), IC7.66 (GND_22), IC7.67 (GND_23), IC7.68 (GND_24), IC7.69 (GND_25), IC7.70 (GND_26), IC7.71 (GND_27), IC7.72 (GND_28), IC7.73 (GND_29), IC7.74 (GND_30), IC7.75 (GND_31), IC7.76 (GND_32), IC7.77 (GND_33), IC7.78 (GND_34), IC7.79 (GND_35), IC7.80 (GND_36), IC7.81 (GND_37), IC7.82 (GND_38), IC7.83 (GND_39), IC7.84 (GND_40), IC7.85 (GND_41), IC7.86 (GND_42), IC7.87 (GND_43), IC7.88 (GND_44), IC7.89 (GND_45), IC7.90 (GND_46), IC7.91 (GND_47), IC7.92 (GND_48), IC7.93 (GND_49), IC7.94 (GND_50), IC7.95 (GND_51), IC7.96 (GND_52), IC8.G0 (GND), IC8.G1 (GND), IC8.G2 (GND), IC8.G3 (GND), IC8.G4 (GND), IC8.G5 (GND), IC8.G6 (GND), J1.2 (GND)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
GND2: IC7.14 (GND_4)
GPIO2: IC7.23 (GPIO2), JP3.2
GPIO3: IC7.24 (GPIO3), JP3.3
GPIO4: IC7.25 (GPIO4), JP3.4
I2S_CLK: IC7.36 (I2S_CLK), JP3.7
I2S_RXD: IC7.37 (I2S_RXD), JP3.8
I2S_TXD: IC7.35 (I2S_TXD), JP3.6
I2S_WA: IC7.34 (I2S_WA), JP3.5
LB: WILDLY_5V_1A_BOOST.3
MC_USB_D+: IC6.1 (1D+), IC8.D+, JP4.3
MC_USB_D-: IC6.2 (1D-), IC8.D-, JP4.2
MIC_BCLK: IC8.9 (9/PWM/RX2/CS0-1), WILDLY_I2S_MIC.3
MIC_DOUT: IC8.13 (13/LED/ALT-PWM/SCK0), WILDLY_I2S_MIC.4
MIC_LRCLK: IC8.23 (23/A9/PWM/T), WILDLY_I2S_MIC.5
M_USB_D+: IC4.3 (ESD3), IC6.3 (2D+), USB.3
M_USB_D-: IC4.2 (ESD2), IC6.4 (2D-), USB.4
unnamed: LED1.C, R1.2
unnamed: IC3.5 (PWRGD), R3.1, R13.2
unnamed: R13.1, R14.2
unnamed: IC2.4 (ESD4), R2.2, X1.SW1
unnamed: C12.2, J1.1 (SIG)
unnamed: C5.2, C12.1, L2.2
unnamed: LED3.C, T1.3 (C)
unnamed: LED3.A, R15.1
NET_STAT: IC5.1 (A1), IC7.16 (GPIO1), R16.2, R17.1, R17.2, T1.1 (B)
PWR_ON: IC1.1 (ESD1), IC7.15 (PWR_ON), IC8.35 (35/A16/PWM), R20.1
RI: IC5.10 (B6), IC8.17 (17/A3/PWM/T/ALT-SDA0)
RI1: IC5.7 (A6), IC7.7 (RI)
RST: IC1.4 (ESD4), IC7.18 (RESET_N)
RTS: IC5.11 (B5), IC8.34 (34/A15/CAN1RX/RX5/ALT-SDA0)
RTS1: IC5.6 (A5), IC7.10 (RTS)
RXD: IC5.14 (B2), IC8.1 (1/TX1/MISO1/T), R6.1, R6.2
RXD1: IC5.3 (A2), IC7.13 (RXD)
SCL: IC7.27 (SCL), R18.2
SDA: IC7.26 (SDA), R19.2
SIM_CLK: C22.2, IC2.3 (ESD3), IC7.38 (SIM_CLK), X1.C3
SIM_DET: C18.2, IC1.3 (ESD3), IC7.42 (SIM_DET), R11.2, X1.SW2
SIM_I/O: C19.2, IC1.2 (ESD2), IC7.39 (SIM_IO), X1.C7
SIM_RST: C21.2, IC2.2 (ESD2), IC7.40 (SIM_RST), X1.C2
STAT: IC5.16 (B1), IC8.24
SW_EN: IC6.6 (!OE), JP2.1
SW_SEL: IC6.9 (S), JP2.2
TXD: IC5.13 (B3), IC8.0 (0/RX1/MOSI1/T), R5.1, R5.2
TXD1: IC5.4 (A3), IC7.12 (TXD)
USB_D+: IC6.8 (D+), IC7.29 (USB_D+)
USB_D+1: JP2.3
USB_D-: IC6.7 (D-), IC7.28 (USB_D-)
USB_GND: C9.2, IC4.5 (GND_A), IC4.6 (GND_B), IC6.5 (GND), IC7.30 (GND_8), JP4.4, USB.1
USB_GND1: JP2.4
V+: C8.1, IC3.1 (!SHDN), IC3.2 (VIN), J2.1, J3.1, SOLAR_CHARGER.1, WILDLY_5V_1A_BOOST.7
VCC: C10.1, IC5.15 (VCCB), IC6.10 (VCC), IC8.3V3(1) (3V3), IC8.3V3(2) (3V3), IC8.3V3(3) (3V3), IC8.3V3(4) (3V3), TP2.TP, TP3.TP, WILDLY_I2S_MIC.1
VCCINT: C3.1, IC5.2 (VCCA), IC5.8 (OE), IC7.4 (V_INT), R2.1, R18.1, R19.1, TP5.TP
VDD: C4.2, C7.1, IC3.4 (VOUT), IC7.51 (VCC_1), IC7.52 (VCC_2), IC7.53 (VCC_3), R3.2, R15.2, TP1.TP
VSIM: C6.2, C20.2, IC2.1 (ESD1), IC7.41 (VSIM), X1.C1
VUSB_DET: C9.1, IC4.1 (ESD1), IC7.17 (VUSB_DET), IC8.VUSB, JP4.1, USB.5
V_BCKP: C16.1, IC7.2 (V_BCKP), R20.2

Notes on the sheet:
SIM CARD
POWER
MICRO USB B
ANTENNA
UART LEVEL SHIFTER
CONNECTORS_1
INDICATION LED's
CONNECTORS 2
VDD = 4.14V VCCINT = 1.8V VCC = 3.3V
IC1
IC2
IC4
USB SWITCH
SARA - U201 GSM Module
Adafruit I2S Microphone SPH0645LM4H
5V Boost 1A
VBAT
GND
VUSB
Fuel Gauge
Solar Charger
5V Out EN - Transmitter On/Off
TEENSY 3.6 - uC Module
IC8 Teensy uC
Power-Boost
I2S Microphone
On/Off Switch

Board: 2 copper layers, 103.9 x 80.0 mm, 62 parts (11 on the bottom side), 63 nets.

File SARA_U201_BREAKOUT_BOARD/GSM-BOM-Final.xlsx:

Wildly_GSM_BOM
S. No | Part | Value | Device | Package | Description | Digikey link | Mnfr P/N | Manufacturer | Quantity
1 | C3,C4,C6,C9,C10 | 100nF | C-EUC0805 | C0805 | CAPACITOR, European symbol
2 | C5 | 15pF | C-EUC0805 | C0805 | CAPACITOR, European symbol
3 | C7 | 2.2uF | C-EUC0805 | C0805 | CAPACITOR, European symbol
4 | C8 | 10uF | C-EUC0805 | C0805 | CAPACITOR, European symbol
5 | C11 |  | C-USC0805 | C0805 | CAPACITOR, European symbol
6 | C12 | 33pF | C-EUC0805 | C0805 | CAPACITOR, European symbol
7 | C13 |  | C-USC0805 | C0805 | CAPACITOR, European symbol
8 | C16 | 100uF | C-USC0805 | C0805 | CAPACITOR, European symbol
9 | C18,C19,C20,C21,C22 | 47pF | C-EUC0805 | C0805 | CAPACITOR, European symbol
10 | IC1,IC2,IC4 | SOT95P275X110-6N | SOT95P275X110-6N | SOT95P275X110-6N | ESD Protection Chip
11 | IC3 | MCP1826T-3302E_DC | MCP1826T-3302E_DC | SOT127P706X180-6N | IC REG LINEAR 3.3V 1A SOT223-5 | https://www.digikey.in/product-detail/en/microchip-technolog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 | MCP1826T-3302E/DC | Microchip Technology
12 | IC5 | TXB0106PWR | TXB0106PWR | SOP65P640X120-16N | IC TRNSLTR BIDIRECTIONAL 16TSSOP | https://www.digikey.in/product-detail/en/texas-instruments/T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 | TXB0106PWR | Texas Instruments
13 | IC6 | TS3USB221ERSER | TS3USB221ERSER | TS3USB221ERSER | IC USB SWITCH DUAL 1X2 10-QFN | https://www.digikey.in/product-detail/en/texas-instruments/T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 | TS3USB221ERSER | Texas Instruments
14 | IC7 | SARA-U201-03B | SARA-U201-03B | SARA-U201-03B
15 | IC8 | TEENSY3_6--ALLPINS | TEENSY3_6--ALLPINS | T36 | Female Headers
16 | J1 | SMA_CONNECTOR | SMA_CONNECTOR | LPRS_SMA_CONNECTOR | CONNECTOR, SMA, ANTENNA
17 | J2 | B2B-PH-SM4-TB(LF)(SN) | B2B-PH-SM4-TB(LF)(SN) | JST_B2B-PH-SM4-TB(LF)(SN) | Lipo connector
18 | J3,J4,J5 | 61300211121 | 61300211121 | 61300211121 | Female Headers of Fuel Gauge
19 | JP2,JP4 |  | PINHD-1X4 | 1X04 | Male Headers
20 | JP3 |  | PINHD-1X9 | 1X09 | Male Headers
21 | L2 | 39nH | SRR1260-470MLQW18AN39NJ8ZD | FB_BLM18PG121SN1D | Inductor Power Shielded Wirewound 33uH 20% 100KHz 27Q-Factor Ferrite 3A 60mOhm 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
22 | LED1 |  | LEDCHIPLED_0805 | CHIPLED_0805 | LED - Green
23 | LED3 |  | LEDCHIPLED_0805 | CHIPLED_0805 | LED - Blue
24 | R1 | 470 | R-EU_R0805 | R0805 | RESISTOR, European symbol
25 | R2,R14 | 1K | R-EU_R0805 | R0805 | RESISTOR, European symbol
26 | R3,R20 | 100K | R-EU_R0805 | R0805 | RESISTOR, European symbol
27 | R4,R5,R6 | 0R | R-US_M0805 | M0805 | RESISTOR, European symbol
28 | R11 | 470K | R-EU_R0805 | R0805 | RESISTOR, European symbol
29 | R13,R17 | 10K | R-EU_R0805 | R0805 | RESISTOR, European symbol
30 | R15 | 820R | R-EU_R0805 | R0805 | RESISTOR, European symbol
31 | R16 | 47K | R-EU_R0805 | R0805 | RESISTOR, European symbol
32 | R18,R19 | 4K7 | R-EU_R0805 | R0805 | RESISTOR, European symbol
33 | SOLAR_CHARGER | 61300211121 | 61300211121 | 61300211121 | 2x1 Headers
34 | SWITCH | GSM Power | EG1218 | 3PIN_SLIDE_SWITCH | On/Off Switch
35 | T1 | BC847 | BC847 | SOT23 | NPN Transistor
36 | TP1,TP2,TP3,TP4 | TPB1,27 | TPB1,27 | B1,27 | Test Points
37 | USB | MICRO-USB-ZX62R-B-5P | MICRO-USB-ZX62R-B-5P | ZX62R-B-5P | Micro USB connector
38 | WILDLY_5V_1A_BOOST |  | PINHD-1X8BIG | 1X08-BIG | Female headers
39 | WILDLY_I2S_MIC |  | PINHD-1X6 | 1X06 | Female headers
40 | X1 | CCM03-3013LFT_R102 | CCM03-3013LFT_R102 | C&K_CCM03-3013LFTR102 | SIM Card Holder

## Commit log (part)

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2018-08-09 Silkscreen_bottom_for_SIMCOM5320e_Breakout_board
2018-08-09 Silkscreen_top_for_SIMCOM5320e_Breakout_board
2018-08-09 Soldermask_bottpm_for_SIMCOM5320e_Breakout_board
2018-08-09 Soldermask_top_for_SIMCOM5320e_Breakout_board
2018-08-09 Solderpaste_bottom_for_SIMCOM5320e_Breakout_board
2018-08-09 Solderpaste_top_for_SIMCOM5320e_Breakout_board
2018-08-13 Add files via upload
    BOM for SIM5330e breakout board
2018-08-13 Add files via upload
    Schematic layout for SIM5330e breakout board
2018-08-13 Add files via upload
    Board layout for SIM5330e breakout board
2018-08-13 Add files via upload
    Copper bottom gerber file for SIM5330e breakout board
2018-08-13 Add files via upload
    Copper top gerber file for SIM5330e breakout board
2018-08-13 Add files via upload
    Drill file for SIM5330e breakout board
2018-08-13 Add files via upload
    Gerber job for SIM5330e breakout board
2018-08-13 Add files via upload
    Profile for SIM5330e breakout board
2018-08-13 Add files via upload
    Silkscreen bottom gerber file for SIM5330e breakout board
2018-08-13 Add files via upload
    Silk screen top gerber file for SIM5330e breakout board
2018-08-13 Add files via upload
    Solder mask bottom gerber file for SIM5330e breakout board
2018-08-13 Add files via upload
    Solder mask top gerber file for SIM5330e breakout board
2018-08-13 Add files via upload
    Solder paste bottom gerber file for SIM5330e breakout board
2018-08-13 Add files via upload
    Solder paste top gerber file for SIM5330e breakout board
2018-08-24 Bill of materials for MEMS MIC breakout board
2018-08-24 Schematic file and save data.
2018-08-24 Board files and save data.
2018-08-24 GERBER files for MEMS MIC.
2018-08-24 Bill of materials for SD card module.
2018-08-24 Schematic file for SD card breakout board
2018-08-24 Board files for SD CARD breakout board
2018-08-24 GERBER files for SD CARD breakout board
2018-08-24 Bill of materials for Serial to FDTI breakout board
2018-08-24 Schematic and save file for Serial to FDTI breakout board
2018-08-24 BOARD and save files for Serial to FDTI breakout board
2018-08-24 Rename SERIAL_TO_FDTI_BREAKOUT_BOARD/GERBER/FTDI Basic-5V.b#3 to SERIAL_TO_FDTI_BREAKOUT_BOARD/FTDI Basic-5V.b#3
2018-08-24 Rename SERIAL_TO_FDTI_BREAKOUT_BOARD/GERBER/FTDI Basic-5V.brd to SERIAL_TO_FDTI_BREAKOUT_BOARD/FTDI Basic-5V.brd
2018-08-24 GERBER files for Serial to FDTI breakout board
2018-08-24 Schematic and save files for Serial to FDTI breakout board
2018-08-24 Board and save files for Serial to FDTI breakout board.
2018-08-24 GERBER files for SIM5320e breakout board
2018-08-24 Bill of materials for SIM5320e breakout board
2018-08-24 Schematic and save file for SIM5320e breakout board
2018-08-24 Board and save files for SIM5320e breakout board
2018-08-24 3D view for MEMS MIC BREAKOUT BOARD
    Open using Sketch up.
2018-08-24 3D view for SD Card BREAKOUT BOARD
    Open using Sketch up.
2018-08-24 3D view for SERIAL TO FDTI BREAKOUT BOARD
    Open using Sketch up.
2018-08-24 3D view for SIM5320e GSM BREAKOUT BOARD
    Open using Sketch up.
2018-08-28 Flow chart for MEMS MIC breakout board
2018-08-28 Flow chart for SD CARD breakout board
2018-08-28 Flow chart for Serial to FTDI breakout board
2018-08-28 Flow chart for SIM5320e breakout board
2018-08-28 Updates on MEMS MIC breakout board
2018-08-28 Updates on SD CARD breakout board
2018-08-28 Updates on aSerial to FTDI breakout board
2018-08-28 Updates on SIM5320e breakout board
2018-09-06 Schematic and save file for MEMS MIC
2018-09-06 Board and save file for MEMS MIC
2018-09-06 3d view file for MEMS MIC
2018-09-06 GERBER files for MEMS mic
2018-09-06 PCB UPDATEDS
    I have added the changes done in MEMS MIC,SIM5320e,SC CARD, Serial to FDTI breakout boards.
2018-09-06 Rename MEMSMIC_-_SD_CARD_INTEGRATION/Readme.txt to MEMSMIC_and_SD_CARD_INTEGRATION/Readme.txt
2018-09-06 Schematic and save file for MEMS MIC and SD CARD
2018-09-06 Board and save file for MEMS MIC and SD CARD
2018-09-17 Rename MEMS_MIC_BREAKOUT_BOARD/GERBER/readme to Readme.txt
2018-09-17 Rename SERIAL_TO_FDTI_BREAKOUT_BOARD/Readme.txt to SERIAL_TO_FTDI_BREAKOUT_BOARD/Readme.txt
2018-09-17 Rename SERIAL_TO_FDTI_BREAKOUT_BOARD/GERBER/Readme.txt to SERIAL_TO_FTDI_BREAKOUT_BOARD/GERBER/Readme.txt
2018-09-17 GERBER files for MEMS MIC breakout board
2018-09-17 Schematic files for MEMS MIC
2018-09-17 Board and save files for MEMS MIC
2018-09-17 Block diagram for MEMS MIC breakout board
2018-09-17 BOM for MEMS MIC breakout board
2018-09-17 Schematic and save files for SIM5320e breakout board
2018-09-17 Schematic files for SD card breakout board
2018-09-17 Board and save files for SD card breakout board
2018-09-17 Gerber files for Serial to FTDI breakout board
2018-09-17 Schematic files for Serial to FTDI breakout board
2018-09-17 Boardfiles for Serial to FTDI breakout board
2018-09-17 Block diagram for for Serial to FTDI breakout board
2018-09-17 Block diagram for SD card breakout board
2018-09-17 Block diagram for SIM5320e breakout board
2018-10-30 BOM for MEMS_MIC breakout board.
2018-10-30 Schematic & save file for MEMS_MIC breakout board.
2018-10-30 Board and save file for MEMS_MIC breakout board.
2018-10-30 GERBER files for MEMS_MIC breakout board.
2018-10-30 GERBER files for SD_CARD breakout board.
2018-10-30 Schematic & save file for SD_CARD breakout board.
2018-10-30 Board & save file for SD_CARD breakout board.
2018-10-30 BOM file for SD_CARD breakout board.
2018-10-30 Schematic for SARA_U201 breakout board
2018-11-14 Board & save files for SARAU201_Breakout board
2018-11-14 Gerber files for SARA_U201 breakout board
2018-11-15 board and save files for SARA_U201
2018-11-15 schematic and board files for SARA_U201
2018-11-15 SCHEMATIC AND BOARD FILES FOR SARA u201
2018-11-16 SCHEMATIC AND BOARD FILES FOR SARA U201
    Updated ground planes.
2018-11-16 GERBER FOR SARA U201
2018-11-20 BOM FOR SARA_U201
2018-11-21 Library files for audiomoth
2018-11-21 Schematic files for audiomoth
2019-02-11 reate symbols for custom PCB for the Teensy setup with I2S mic
2019-02-14 Add more connections to Teensy
2019-02-14 Remove extra SMA connector
2019-02-19 Add more connections and adjust layour inlcude room for board fitting
2019-02-20 Tidy up and complete schematics for review
2019-02-20 Fix/Swap RTS and CTS connections
2019-02-23 Compoenent placement, Ground plane, drill holes etc on the layout
2019-02-26 Clean schematics after review with Hari on 25/2/2019, BOM to be prepared
2019-02-27 Add Jumper to unify power supply for both recorder and GSM when needed, add LEDS for power switches, add caps for supply input
2019-03-05 Remove LEDs for Power Enables, Remove LEDs for Low Bat indicators, Add NPN Transistors as LED drivers - TBD: Calculate R values, Remove Power LED and change pinout to power control for resetting syst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
2019-03-05 Add resistor values for LED driver, remove previous board file due to inconsistency and create a fresh layout from schematics
2019-03-07 Add BOM file, fix R value for LED driver, start component placement in layout
2019-03-11 Add routing, clear DRC with sparkfun design rules
2019-03-14 Fix power line, change layout according to review with Hari on 11/3/2019. TBD: BOM finalization and final footprint alignment
2019-03-15 Add copper pours, resize board, adjust routing for sufficient spacing etc
2019-03-18 Create BOM file in excel format
2019-04-01 Add latest files from Aakash Nasa with updatest to schamtic and layout to include: Pinouts for unused pins from Teensy, changes to BOM according to component availabilityetc
2019-04-03 Teensy Proto schematic and Layout File updated
2019-04-03 Updated Layout with changed footprint for level shifters and SARA-U201
2019-04-04 Added different switch footprints
2019-04-05 Power section shifted to one side along with LED's shifted downand track width increased
2019-04-08 Added new transistor BC847 along with some 0R reistors
2019-04-08 Changed all the power symbols to +5V and 3V3 accordingly
2019-04-08 Generate gerbers
2019-04-10 Positioning of filter capacitors along with connections corrected
2019-04-10 Move capacitors and resistors in layout according to flow of signal as in schematics, rename net names, increase mount hole diameters
2019-04-18 Added the USB switch and power LED
2019-04-19 Rx and Tx connections interchanged and positioning of fuel gauge adjusted
2019-04-22 Changed the pad for L2 and used minimum no. of vias to connect to the USB switch
2019-04-24 Added the fuel Gauge circuit on board and rearranged the Transistors for grouping and short routing to the LEDs
2019-05-13 Added Teensy, MIC, Boost connectors along with some layout changes with USB switch and rerouting all the connections
2019-05-13 Removed the RST pin connection from Teensy as it requires a level shifter
2019-05-14 Fuel gauge with a different IC to measure current
2019-05-24 All the review changes done except a few which need to be discussed
2019-05-24 Updated the BOM as well with the schematics and layout
2019-05-29 Proto board only for recording GSM circuit removed
2019-05-29 Finalized Proto board with 3 way and 2 way switches included for on/off GSM and for on/off/test the board
2019-05-29 Bin pin pulled down to Vss by 10K resistor
2019-05-29 Minor changes done like the net name changed
2019-05-30 Powerboost with pin configurations matched with Proto Board
2019-05-30 Solar Charger board with minor changes
2019-05-30 Both 0805 and 0603 resitors layout present for I2S Mic
2019-05-30 Powerboost with some minor changes from original
2019-06-13 Fix Silkscreen issues with Solar board
2019-06-13 Rework recroder board to be more compact, remove unnecessary components etc
2019-06-14 Add GSM pinouts, clean signals and silk screen, etc
2019-06-19 Add GSM signals, rerouting for space efficiency and minor changes for fabrication
2019-06-19 Add RTC pinouts and associated silkscreen
2019-06-21 REmove Silkscreen and other placement issues in Powerboost basic
2019-06-25 Create a multiple LiPo battery charging board
2019-06-26 Remove gorund plane and connect grounds directly, add reverse current protection, add jumpers to isolate individual batteries and main power if needed
2019-06-26 Remove jupers and place diode appropriately to prevent reverse current, remove ground looping
2019-06-26 Remove ground routing from under the diode, remove more ground looping near battery connectors
2019-07-05 Create GSM daughter board with Mikrobus format
2019-08-23 Added BOM for I2S mic for 0603 components
2019-08-23 Added wildly recorder BOM
2019-08-23 Added BOM for multiple lipo charger board
2019-09-03 v2 of Wildly Listen Recorder with integrated Fuel gauge and RTC
2019-09-30 Rename file name appropriately
